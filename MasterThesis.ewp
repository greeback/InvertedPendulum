# IAR project MasterThesis.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401VC ST STM32F401VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F4XX
  ICCARM.CCIncludePath2: $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: MasterThesis.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group CMSIS
    ./: system_stm32f4xx.c
  group EWARM
    ./: startup_stm32f401xc.s
  group User
    ./: delay.c fuzzy_pid.c L3GD20.c Led.c LSM303DLHC.c main.c motors.c pid.c stm32f4_gpio.c stm32f4_i2c.c stm32f4_spi.c stm32f4xx_it.c
